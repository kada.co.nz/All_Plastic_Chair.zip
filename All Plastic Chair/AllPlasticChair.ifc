Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T13:21:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 13:21:39 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{A2687926-94E9-4887-9125-D70B9FDBBAFE}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 13:21:38 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 13:21:39 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 13:21:39 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: All Plastic Chair, CONV_Vitra_DmstcChrs_AllPlasticChair:All Plastic Chair:360595
In: Level 1
Material: Plastic buttercup
Pset_ManufacturerTypeInformation - ModelReference: 44038800; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.86735 m2; Volume: 0.14801 m3
Materials and Finishes - ChairMainMaterial: Plastic buttercup
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_AllPlasticChair: All Plastic Chair; Family and Type: CONV_Vitra_DmstcChrs_AllPlasticChair: All Plastic Chair; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_AllPlasticChair: All Plastic Chair; Type Id: CONV_Vitra_DmstcChrs_AllPlasticChair: All Plastic Chair; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_AllPlasticChair; ConvergoRefNr: 0089-1812-0143-CH; ManufacturerName: Vitra; ManufacturerURL: www.vitra.com; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Designed by Jasper Morrison, the All Plastic Chair is reminiscent of classic wooden chairs while advancing the appearance and functionality of this typology. The graceful chair combines great stability with excellent comfort; its backrest is attached to the frame with resilient connectors that allow it to flex in response to the sitter's movements. The All Plastic Chair comes in a choice of two-tone colours and is suited for both indoor and outdoor use.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 18/12/2018
Identity Data(Type) - Collection: All Plastic Chair; Cost: 0; Description: Designed by Jasper Morrison, the All Plastic Chair is reminiscent of classic wooden chairs while advancing the appearance and functionality of this typology. The graceful chair combines great stability with excellent comfort; its backrest is attached to the frame with resilient connectors that allow it to flex in response to the sitter's movements. The All Plastic Chair comes in a choice of two-tone colours and is suited for both indoor and outdoor use.; Designer: Jasper Morrison; Manufacturer: Vitra; Model: All Plastic Chair; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/1361894/storage/master/download/FS_All_Plastic_Chair-EN_Preview-Single-Page.pdf; Type Name: All Plastic Chair; URL: https://www.vitra.com/en-un/living/product/details/all-plastic-chair
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_AllPlasticChair; Features: n/a; Finish: Dyed-through polypropylene; Grade: n/a; Material: Plastic; ModelNumber: n/a; ModelReference: 44038800; Name: DmstcChrs_AllPlasticChair; ReplacementCost: n/a; Shape: Sculptured; Size: 425x460x760 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
